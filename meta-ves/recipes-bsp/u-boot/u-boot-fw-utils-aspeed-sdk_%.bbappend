FILESEXTRAPATHS:prepend := "${THISDIR}/u-boot-aspeed-sdk:"
SRC_URI += "file://ves-vss2249p.cfg"
